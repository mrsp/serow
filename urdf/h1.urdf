Commit message: h1 has flight phases - fix in LegOdometry

File: urdf/h1.urdf (robot description, URDF)
Before this commit: robot h1, 25 links, 24 joints
Joints:
- joint logo_joint: origin xyz=0. 0. 0. rpy=0. 1.5707963 0.  -> xyz=0. 0. 0. rpy=0. 1.5707964 0. 
